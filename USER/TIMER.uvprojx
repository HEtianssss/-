# Keil uVision project TIMER.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIMER +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\GPS;..\HARDWARE\ADXL345;..\HARDWARE\DS18B20;..\HARDWARE\SIM900A;..\HARDWARE\ATONENET1;..\HARDWARE\BUZZER;..\HARDWARE\HRREST_LM393;..\HARDWARE\OLED4P096;..\HARDWARE\ADC_DMA2;..\HARDWARE\HC_SR04_1;..\HARDWARE\JQ8400_Com
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/ADXL345/: adxl345.c
    ../HARDWARE/OLED4P096/: oled_iic.c
    ../HARDWARE/SIM900A/: sim900a.c
    ../HARDWARE/ADC_DMA2/: adc_dma.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/HC_SR04_1/: hc_sr04.c
    ../HARDWARE/JQ8400_Com/: JQ8400_COM.c
    ../HARDWARE/GY906/: smbus.c smbus.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c
